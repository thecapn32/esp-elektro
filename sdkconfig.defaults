## sdkconfig.defaults
```kconfig
CONFIG_EXAMPLE_I2C_ADDR=0x60
CONFIG_EXAMPLE_I2C_MASTER_SCL=7
CONFIG_EXAMPLE_I2C_MASTER_SDA=6

CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
```
